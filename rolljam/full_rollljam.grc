options:
  parameters:
    generate_options: qt_gui
    id: rolling_code_grabber
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate_jammer
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: samp_rate_listener
  id: variable
  parameters:
    value: 1e6
  states: {state: disabled}
- name: signal_freq
  id: variable
  parameters:
    value: 5000e3
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 435.5e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1000'
    freq: signal_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_jammer
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/test.rec
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '8'
    type: int
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_jammer
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1,0,0,1,0)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '120000'
    decim: '1'
    gain: '6'
    samp_rate: samp_rate_listener
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: Sniffer
  states: {}
- name: note_1
  id: note
  parameters:
    note: Jammer
  states: {}
- name: note_3
  id: note
  parameters:
    note: Replay the sampled data
  states: {}
- name: note_4
  id: note
  parameters:
    note: A little frequency shifting to avoid DC offset issue
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '62'
    freq0: tx_freq-signal_freq
    gain0: '14'
    if_gain0: '47'
    sample_rate: samp_rate_jammer
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 4337e5
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 433.85e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate_listener
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_repeat_0, '0', blocks_float_to_complex_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_1, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
